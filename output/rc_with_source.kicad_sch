File: output/rc_with_source.kicad_sch (KiCad schematic)
At the start: 3 parts

Commit message: fix: update pipelines
Connections:
- net VOUT: no longer C1.1
